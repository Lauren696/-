# Keil uVision project 13054045.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 13054045 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP;..\LIB;..\USER
  group USER
    ./: main.c
  group APP
    ../APP/: led.c led.h smg.c smg.h timer.c timer.h key.c key.h
  group LIB
    ../LIB/: ds1302.c ds1302.h onewire.c onewire.h
